## boards/shields/artpad/Kconfig.defconfig
```kconfig
if SHIELD_ARTPAD

config ZMK_KEYBOARD_NAME
    default "ArtPad"

endif # SHIELD_ARTPAD
```
